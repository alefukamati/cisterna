#include <WiFi.h>
#include <WebServer.h>
#include <SPIFFS.h>
#include <SPI.h>
#include <Wire.h>
#include <Adafruit_GFX.h>
#include <Adafruit_SSD1306.h>

#ifndef STASSID
#define STASSID "" //Nome da sua rede
#define STAPSK "" //senha da sua rede
#endif

#define READ_TRY 30
#define LED_BUILTIN 2
#define LED_S1 25
#define LED_S2 26

#define SCREEN_WIDTH 128
#define SCREEN_HEIGHT 64 
#define OLED_RESET     -1 


#define sensor1 32
#define sensor2 33


const char* ssid = STASSID;
const char* password = STAPSK;

uint16_t s_total = 0;

static const uint8_t cisterna2[1024] = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7c, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x1f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xfc, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xf8, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x0f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xf8, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xfc, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xf8, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xf8, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x1f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x0f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xc0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xc0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x07, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

static const uint8_t cisterna0[1024] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7e, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x3f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7c, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x1f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xfc, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x1f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xf8, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x0f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xf8, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xe0, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

static const uint8_t cisterna1[1024] = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
    0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};


WebServer server(80);
Adafruit_SSD1306 display(SCREEN_WIDTH, SCREEN_HEIGHT, &Wire, OLED_RESET);


void setup() {
  Serial.begin(115200);

  //setar sensores
  pinMode(sensor1, INPUT);
  pinMode(sensor2, INPUT);
  //pinMode(sensor3, INPUT);

  // prepare LED
  pinMode(LED_BUILTIN, OUTPUT);
  pinMode(LED_S1, OUTPUT);
  pinMode(LED_S2, OUTPUT);
  digitalWrite(LED_BUILTIN, 0);
  digitalWrite(LED_S1, 0);
  digitalWrite(LED_S2, 0);
  WiFi.mode(WIFI_STA);
  WiFi.begin(ssid, password);

  if(!display.begin(SSD1306_SWITCHCAPVCC, 0x3C)) { 
    Serial.println(F("SSD1306 allocation failed"));
    for(;;); // Don't proceed, loop forever
  }
  display.clearDisplay();
  display.setTextSize(1);         
  display.setTextColor(WHITE); 
  while (WiFi.status() != WL_CONNECTED) {   
    display.setCursor(0, 10);       
    display.println("CONECTE-SE A UMA REDE");
    display.display();
    delay(500);
    Serial.print(F("."));
  }
  Serial.println();
  Serial.println(F("WiFi connected"));

  server.on("/", handle_OnConnect);
  server.onNotFound(handle_NotFound); 
  // Start the server
  server.begin();
  Serial.println(F("Server started"));
  Serial.println(WiFi.localIP());
  display.clearDisplay();
  display.setTextSize(1);         
  display.setTextColor(WHITE);    
  display.setCursor(0, 10);       
  display.println("Endereco: ");
  display.println(WiFi.localIP());
  display.display();
}

void loop() {
  display.clearDisplay();
  display.setCursor(0, 10);       
  display.println("Endereco: ");
  display.println(WiFi.localIP());
  if ((digitalRead(sensor1)+digitalRead(sensor2)) == 1){
   digitalWrite(LED_S1, 1);
   digitalWrite(LED_S2, 0);
   display.drawBitmap(0, 0, cisterna0, 128, 64, 1);
  }
  else if ((digitalRead(sensor1)+digitalRead(sensor2)) == 2){
   digitalWrite(LED_S1, 1);
   digitalWrite(LED_S2, 1);
   display.drawBitmap(0, 0, cisterna1, 128, 64, 1);
  }
  else{
   digitalWrite(LED_S1, 0);
   digitalWrite(LED_S2, 0);
   display.drawBitmap(0, 0, cisterna2, 128, 64, 1);
  }
  display.display();
  server.handleClient(); //Chama o método handleClient()
  //aumenta o tmepo de tolerancia até definir como timeout
}

int calc_volume(){
  int vol = 0;
  uint8_t n0 = 0;
  uint8_t n1 = 0;
  uint8_t n2 = 0;
  int maior = 0;
  int maior_n = 0;
  int s1 = 0;
  int s2 = 0;

  for(int i = 1; i<READ_TRY; i++){
    s1 = digitalRead(sensor1);
    s2 = digitalRead(sensor2);
    vol = s1+s2; 
    if(vol == 0) n0 += 1;
    if(vol == 1) n1 += 1;
    if(vol == 2) n2 += 1;
  }
  int numeros[3] = {n0, n1, n2};
  for(int i = 0; i <= 2; i++){
    if(numeros[i] > maior){
       maior = numeros[i];
       maior_n = i;
    }
  }
  Serial.print("Niveis: ");
  Serial.println(maior_n); 
  return maior_n;
}


void handle_OnConnect() {
  uint8_t s1 = 0;
  uint8_t s2 = 0;
  int vol_nivel = 0;
  digitalWrite(LED_BUILTIN, 1);
  vol_nivel = calc_volume();
  server.send(200, "text/html", EnvioHTML(vol_nivel));
 //Envia as informações usando o código 200, especifica o conteúdo como "text/html" e chama a função EnvioHTML

}

void handle_NotFound() { //Função para lidar com o erro 404
  server.send(404, "text/plain", "Não encontrado"); //Envia o código 404, especifica o conteúdo como "text/pain" e envia a mensagem "Não encontrado"

}



String EnvioHTML(float vol_nivel) { //Exibindo a página da web em HTML
  String ptr = "<!DOCTYPE html> <html>\n"; //Indica o envio do código HTML
  ptr += "<head><meta name=\"viewport\" content=\"width=device-width, initial-scale=1.0, user-scalable=no\">\n"; //Torna a página da Web responsiva em qualquer navegador Web
  ptr += "<meta http-equiv='refresh' content='3'>";//Atualizar browser a cada 3 segundos
  ptr += "<link href=\"https://fonts.googleapis.com/css?family=Open+Sans:300,400,600\" rel=\"stylesheet\">\n";
  ptr += "<title>Monitor de nível de água</title>\n"; //Define o título da página

  //Configurações de fonte do título e do corpo do texto da página web
  ptr += "<style>html { font-family: 'Open Sans', sans-serif; display: block; margin: 0px auto; text-align: center;color: #000000;}\n";
  ptr += "body{margin-top: 50px;}\n";
  ptr += "h1 {margin: 50px auto 30px;}\n";
  ptr += "h2 {margin: 40px auto 20px;}\n";
  ptr += "p {font-size: 24px;color: #000000;margin-bottom: 10px;}\n";
  ptr += "</style>\n";
  ptr += "</head>\n";
  ptr += "<body>\n";
  ptr += "<div id=\"webpage\">\n";
  ptr += "<h1>Monitor de nivel</h1>\n";
  ptr += "<h2>Cisterna</h2>\n";

  //Exibe as informações de temperatura e umidade na página web
  ptr += "<p><b>Volume: </b>";
  ptr += (float)(vol_nivel/2)*100;
  ptr += " %</p>";

  ptr += "</div>\n";
  if (vol_nivel == 0) ptr += "<img src=data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAhQAAAKOCAIAAABx5ReXAAAAAXNSR0IArs4c6QAAAARnQU1BAACxjwv8YQUAAAAJcEhZcwAAEnQAABJ0Ad5mH3gAABYASURBVHhe7dXbctvIskXR8/8/vQ/dMTMMd8u2SiJIXMZ4XBkhEUBVrv/7HwAsUh4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMeACxTHgAsUx4ALFMe3N3/wQ103J/nT3+x/wnA+bXZn+S3f67/BsAltNyfRHkA3ELL/UmUB8D1tdmf509/sf8Jl9Zxh6voZG80eKqF8igF4MBa2aP02RbK46EBAEfVvh6lz/aXv9s/H6UAHFX7epQ+m/IAuI6W9SjdgfIAuI6W9SjdgfIAuI6W9SjdwVp5PDQA4GBa0xsNdvD3P91PGKUAHExrepTuQ3kAXERrepTuQ3kAXERrepTuY7k8HhoAcBgt6I0G+/jUX++HjFIADqMFPUp3ozwArqAFPUp3ozwATq/tvNFgN8oD4PTazqN0T18pj4cGABxAq3mU7umz/6NfNEoBOIBW8yjdk/IAOLf28kaDPSkPgHNrL4/SnX2xPB4aAPBWLeVRurOFf9PvGqUAvFVLeZTuTHkAnFgbeZTuT3kAnFgbeZTuT3kAnFgbeZTu7+vl8dAAgHdoF2802N/af+rXjVIA3qFdPEpfQnkAnFW7eJS+hPIAOKt28Sh9iW+Vx0MDAF6rLbzR4CWW/1m/cZQC8Fpt4VH6KsoD4JTawqP0VZQHwPm0gjcavIryADifVvAofaHvlsdDAwBepf07Sl/oK/+yHztKAXiV9u8ofSHlAXAyLd+NBi+kPABOpuU7Sl/rCeXx0ACA/bV5R+lrffG/9pNHKQD7a/OO0tdSHgBn0todpS+nPADOpLU7Sl9OeQCcSWt3lL7cc8rjoQEAu2nhbjR4ua//4374KAVgNy3cUfoOygPgNFq4o/QdlAfAabRwR+k7KA+Ac2jbjtI3+da/7wlGKQA7aNWO0jdRHgDn0KodpW+iPABOoD270eBNlAfACbRnR+n7PLM8HhoA8FQt2VH6Pt/9BT3HKAXgqVqyo/R9lAfA0bVhNxq8j/IAOLo27Ch9K+UBcHRt2FH6Vk/4ET3NKAXgSVqvo/StlAfAobVbR+m7KQ+AQ2u3jtJ3Ux4Ah9ZuHaXv9vzyeGgAwPe0VTcavNtzfkfPNEoB+J626ig9AOUBcFxt1VF6AMoD4LjaqqP0AJQHwEG1UkfpMTzt1/RwoxSAr2qfjtJjUB4AB9U+HaXHoDwAjqhlutHgGJQHwBG1TEfpYexVHg8NAFjXJh2lh/HMH9QjjlIA1rVJR+lhKA+Aw2mNbjQ4DOUBcDit0VF6JMoD4HBao6P0SJ78m3rQUQrAinboKD0S5QFwLC3QUXowygPgWFqgo/RglAfAsbRAR+nB7FseDw0A+IRW50aDg3n+z+pxRykAn9DqHKXHozwADqTVOUqPR3kAHEirc5Qej/IAOIr25ig9pF1+XM89SgH4o5bmKD0k5QFwFC3NUXpIygPgENqYGw0OSXkAHEIbc5Qe1SvK46EBAL/RuhylR7XX7+vpRykAv9G6HKVHpTwA3q9dudHgqJQHwPu1K0fpgSkPgPdrV47SA3tReTw0AOA/WpSj9MB2/Im9g1EKwK/akqP02JQHwJu1JUfpsSkPgDdrS47SY3tdeTw0AGC0HzcaHNu+v7I3MUoBGO3HUXp4ygPgndqPo/TwlAfAO7UfR+nhKQ+At2k5jtIzeGl5PDQAQHn8Qa9klAKgPP6gVzJKAW6vtbjR4AyUB8B7tBZH6Um8ujweGgDcWztxlJ7EK35uL2aUAtxbO3GUnoTyAHiDFuJGg5NQHgBv0EIcpeehPADeoIU4Ss/jDeXx0ADgrtqGo/Q8XvSLez2jFOCWWoWj9FSUB8CrtQpH6akoD4BXaxWO0lN5T3k8NAC4mZbgRoNTed2P7iWNUoCbaQmO0rNRHgAv1RIcpWejPABeqiU4Ss9GeQC8ThtwlJ7Q28rjoQHAbbT+RukJvfSn97ZGKcBttP5G6QkpD4AXafdtNDgh5QHwIu2+UXpO7yyPhwYAN9DiG6Xn9Opf3zsbpQA30OIbpeekPABeoa230eCclAfAK7T1RulpKQ+AV2jrjdLTenN5PDQAuLRW3ig9rTc8QG9ulAJcV/tulJ6Z8gDYXftulJ6Z8gDYXftulJ7Z+8vjoQHAFbXpNhqc2Xueofc3SgGuqE03Sk9OeQDsq003Sk9OeQDsq003Sk9OeQDsqDU3Ss/vEOXx0ADgWtpxo/T83vYkvchRCnAt7bhRen7KA2AvLbiNBuenPAD20oIbpZegPAD20oIbpZfwzofpdY5SgKtou43SS1AeALtotW00uATlAbCLVtsovQrlAbCLVtsovYoDlcdDA4CTa6ltNLiKNz9PL3WUApxcS22UXojyAHi+ltoovRDlAfB8LbVReiHKA+DJ2mgbDS7k/Y/Uqx2lAKfVOhul16I8AJ6sdTZKr0V5ADxZ62yUXovyAHimdtkovZzDlcdDA4ATapGN0ss5xIP1jkcpwAm1yEbp5SgPgKdpi200uBzlAfA0bbFRekXKA+Bp2mKj9IqO8my96VEKcCqtsFF6RcoD4DnaXxsNrkh5ADxH+2uUXpTyAHiO9tcovaiDlsdDA4AzaHNtNLioAz1e73uUApxBm2uUXpfyAHiCNtcovS7lAfAEba5Rel3KA+C7WlsbDa7rWE/YWx+lAMfWzhqll6Y8AL6rnTVKL015AHxXO2uUXpryAPiWFtYovbpDl8dDA4CjaluN0qs73HP2+kcpwFG1rUbp1SkPgK9rVW00uDrlAfB1rapRegPKA+DrWlWj9AaO+Kh9hFEKcDztqVF6A8oD4ItaUqP0HpQHwBe1pEbpPSgPgC9qSY3SezhBeTw0ADiM1tNGg3s46NP2KUYpwGG0nkbpbSgPgK9oPY3S21AeAF/Rehqlt6E8AJa1mzYa3MY5yuOhAcABtJhG6Z0c95n7JqMU4ABaTKP0TpQHwLIW0yi9E+UBsKatNEpv5jTl8dAA4K1aSaP0Zg792H2ZUQrwVq2kUXozygNgQftoo8HNKA+ABe2jUXo/ygNgQftolN7PmcrjoQHAm7SMRun9HP3J+z6jFOAd2kSj9JaUB8BntYlG6S0pD4DPahON0ls6WXk8NAB4rXbQRoNbOsHD95VGKcBrtYNG6V0pD4BPaQeN0rtSHgCf0g4apXelPAD+rgW00eCuzlceDw0AXqXtM0pv7ByvoM81SgFepe0zSm9MeQD8XdtnlN6Y8gD4i1bPKL23U5bHQwOA/bV3Rum9neYt9NFGKcD+2juj9N7OWh58qJcFPE+3a6PBvSkPwDb8k97RKL095QGwoJV0e8oDYEEr6fbO9CL6dABv0jLi1OVRykavBthHNw3lATx0qfib3henLo+HBgA7aNFsNOBc5fHQBxylADto0YxS/qE8AD7Wohml/EN5AHysRTNK+YfyAPhAW2ajAf84d3k8NAB4qlbMKGWc7430JUcpwFO1YkYpQ3kAfKAVM0oZygPg39ovo5SN05fHQwOAJ2m5jFI2TvlS+p6jFOBJWi6jlA3lAfCLNstGAzaUB8Av2iyjlF8pD4BftFlGKb+6Qnk8NAD4ttbKKOVXZ30vfdVRCvA97ZRRyn8oD4Cf2imjlP9QHgA/tVNGKf+hPADSQtlowH+c+NX0bUcpwFe1TUYpH1EeAGmbjFI+ojwA0jYZpXxEeQD80CrZaMBHrlMeDw0A1rVHRim/ce4X1EcepQDr2iOjlN9QHgA/tEdGKb+hPAAsk2XKA8AyWXb6d9SnHqUAK9ogo5TfUx7A3bU+Nhrwe8oDuLvWxyjlj5QHcHetj1HKH12tPB4aAHxOu2OU8kdXeE198FEK8AktjlHK3ygP4NZaHKOUv1EewK21OEYpf6M8gPtqa2w04G8u8qb67KMU4I9aGaOUT1AewH21MkYpn6A8gPtqZYxSPkF5ADfVvthowCdcszweGgD8RstilPI513lfff9RCvAbLYtRyucoD+CmWhajlM9RHsAdtSlGKZ+mPIA7alOMUj7tUq+sUzBKAf6jNTFK+TTlAdxOO2KjAZ+mPIDbaUeMUlYoD+B22hGjlBVXLo+HBgAbLYhRyoqrvbXOwigFGG2HUcoi5QHcS9thlLJIeQD30nYYpSxSHsCNtBo2GrDogi+uEzFKAeyH51EewI20F0Yp65QHcCPthVHKOuUB3EVLYaMB665fHg8NgHtrI4xSvuSar6+jMUqBe2sjjFK+RHkAt9A62GjAlygP4BZaB6OUr1IewC20DkYpX3WL8nhoANxVu2CU8lWXfYMdkFEK3FKLYKMBX6U8gOtrEYxSvkF5ANfXIhilfMNdyuOhAXA/bYFRyjdc+SV2TEYpcDOtgFHK9ygP4OJaAaOU71EewMW1AkYp36M8gCvr/m804HtuVB4PDYDb6PKPUr7t4q+y8zJKgdvo8o9Svk15AFfW5R+lfJvyAC6rm7/RgG+7V3k8NABuoGs/SnmG67/NTs0oBW6gaz9KeQblAVxTd36jAc+gPIBr6s6PUp5EeQDX1J0fpTzJ7crjoQFwaV34UcqT3OKFdnZGKXBd3faNBjyJ8gAuqNs+Snke5QFcULd9lPI8dyyPhwbARXXVRynPc5d32gkapcAVdc9HKU+lPICr6Z6PUp5KeQBX0z0fpTyV8gAupUu+0YCnuml5PDQArqUbPkp5thu92Y7SKAWupRs+Snk25QFcSjd8lPJsygO4jq73KGUH9y2PhwbAVXS3Ryk7uNfL7UCNUuAqutujlB0oD+AiutgbDdiB8gAuoos9StmH8gAuoos9StnHrcvjoQFwft3qUco+bvd+O1ajFDi5rvRGA/ahPIAr6EqPUnajPIAr6EqPUnZz9/J4aACcWfd5lLKbO77iDtcoBU6ryzxK2ZPycM7g9LrMo5Q9KQ/nDE6vyzxK2ZPycM7g3LrJGw3Yk/L4oQFwQl3jUcrObvqiO2WjFDihrvEoZWfK44dS4IS6xqOUnSmPH0qBs+kOj1L2pzx+KAXOpjs8Stnffd91Z22UAqfSBR6l7E95pBQ4j27vRgP2pzxSCpxHt3eU8hLKI6XAeXR7RykvoTx+agCcRFd3lPISt37dnbhRCpxB93ajAS+hPH4qBc6geztKeRXl8VMpcAbd21HKqyiPn0qBM+jejlJe5e5vvHM3SoFj68aOUl5IefyiFDi2buwo5YWUxy9KgWPrxo5SXkh5/KIUOLCu60YDXkh5/FsD4Ki6q6OU1/LeHUQ4me7qKOW1vHcHEU6muzpKeS3v3UGEM+mijlJezqt3FuFMuqijlJfz6n/oGI5S4Hi6paOUl/Pqf+gYjlLgYLqiGw14Oa/+h47hKAUOpis6SnkHb/+HTuIoBQ6mKzpKeQdv/4dO4kYD4Ei6n6OUd/D202EcpcBhdDk3GvAO3n46jKMUOIwu5yjlTXyAdB5HKXAYXc5Rypv4AOk8jlLgMLqco5Q38QF+6kiOUuAAupajlPfxDX7qVI5S4AC6lqOU9/ENfupUjlLgALqWo5T38Q1+6lSOUuDdupMbDXgf3+CnTuVGA+CtupCjlLfyGX7R2RylwFt1IUcpb+Uz/KKzOUqBt+pCjlLeymf4RWdzlALv020cpbybL/GLjucoBd6n2zhKeTdf4t86oaMUeJOu4ijl3XyJf+uEjlLgHbqHGw14N1/i3zqhoxR4h+7hKOUAfIx/65COUuAduoejlAPwMf6tQ7rRAHi5LuEo5QB8jA90Tkcp8FrdwI0GHICP8YHO6SgFXqsbOEo5Bt/jAx3VUQq8VjdwlHIMvse/dU43GgCv1Q0cpRyD7/FvndNfNQNepbs3SjkMn+TfOqq/aga8SndvlHIYPskHOq0bDYBX6e6NUg7DJ/lAp3WjAfASXbyNBhyGT/KBTusoBV6luzdKORJf5WOd2VEKvEQXb5RyJL7KxzqzoxR4iS7eKOVIfJWPdWZHKbC/bt0o5WB8mN/q5I5SYGdduVHKwfgwv9XJHaXAzrpyo5SD8WF+q5M7SoE9dd82GnAwPsyfdHhHKbCbLtso5Xh8mz/p/I5SYDddtlHK8fg2f9L5HaXAbrpso5Tj8W3+oiM8SoEddM02GnA8vs1fdIRHKbCDrtko5ZB8nr/oFI9SYAdds1HKIfk8f9dBHqXAs3XHRimH5PP8XQd5lAJP1QUbpRyVL/R3neVRCjxVF2yUclS+0Kd0nEcpvE9n8bp6To7KF/qUjvMovZaeDY6hc8lR+UKf0nEGXqW7x1H5Qp/ViQZeoovHUflCCzrUwM66chyYj7Sgcw3H0LmEd3D+1nRrL6qHBPgb+wKAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgGXKA4BlygOAZcoDgEX/+9//AwXW7Ko2oasfAAAAAElFTkSuQmCC width = 420 height = 610>" ;
  if (vol_nivel == 1) ptr += "<img src=data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAhQAAAKOCAIAAABx5ReXAAAAAXNSR0IArs4c6QAAAARnQU1BAACxjwv8YQUAAAAJcEhZcwAAEnQAABJ0Ad5mH3gAAA6/SURBVHhe7d3RdeNGEobRoYPYFDa0jcmhOQUnoR2btKyBJBI/CXRXd9/7snrcc0jiQ1cB48vb29sPAEj8dvtfANhNPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxC5vb2+3P2FJl8vl9hfM6/BL/b14+FEBTOPYfnw7tlIOAL5j5wFATDwA5mfnAQc7/EcFfX2+dJ/xJQ/i4TcGUF+bS3cwtnIQAeDqXjwcNQD4koU5wDyarRvEA4CYeAAQy+JhZw5QVstL9IN42JkDDOrUC7ixFQAx8QAgFsfD2gOgoMYX58fxsPYAGM7Zl25jKwBi4gEwvPYLBfEAmE2DdcMz8bAzB1jcrnjYmQPwkbEVwNi6TIPEA2AqbWZFT8bD2gNgZXvjYe0BwDtjK4CBbeZAzW70xQOAmHgAEHs+HnbmAH11vA4H8bAzB6is5VXa2AqAmHgAEHspHtYeAL30vQJn8bD2AKip8fXZ2AqAmHgAjKf71kA8AIbXfqfwajzszAEWFMfDzhwAYyuAwVQY+YgHwNi6DIQOiIe1B8BqnomHtQfA4oytAEayGfb0upsXDwBi4gFA7Jh42JkDNFDnYvtkPOzMAbrreCk2tgIgJh4AxMQDYAxFHtK9ej4em//fduYA63DyACAmHgADqDbdEQ+A8XR/X+LIeFh7ACzipXh4VRBgTcZWANUVnOuIB8BgKkx9xAOA2Kvx8KogwIKcPABK29yUF3lSSTwAiIkHALHj42HtAXCUslfUA+LhVUGANupcb42tAIiJBwAx8QAoquZDulfHxMOrggBLcfIAICYeABUVH+GIB8AAqr0UcVY8rD0AJnZYPLwqCLAOYyuAcuoPb8QDoLqCox3xACB2ZDy8KgiwCCcPgFo2d941H0cSDwBi4gFA7Nx4WHsAREa5bB4cD68KAhyo7EXV2AqAmHgAEBMPgCqGeEj36vh4eFUQYHpOHgDExAOghLHmNOIBUFHxNx9axMPaA2Ayp8TDq4IAczO2AuhvuAmNeACUU39+Ix4AxBrFw84cYCZnxcPOHGCnze31ENdPYysAYuIBQKxdPKw9AD4b9Np4YjysPQBSo1w5ja0AiIkHADHxAOhmxId0r5rGw84cYA7nxsPOHGBKxlYAfQw9jBEPgBLGGtW0joe1B8AETo+HtQfAfIytADoYfQwjHgD9DTekEQ8AYh3iYWcOMLoW8bAzB/hocw894kXS2AqAmHgAEOsTD2sPYFlzXAAbxcPaA+BLg14eja0AiIkHADHxAGhngod0r7rFw84cYFzt4mFnDjANYyuARmaauIgHQB9Dz2N6xsPaA2BQTeNh7QEwB2MrgBYmm7WIB0AHo09ixAOAWOd42JkDjKh1POzMgQVtbpQnuBIaWwEQEw8AYv3jYe0BzG3Kq1yHeFh7ACub4xpobAVATDwAiIkHwInme0j3qkQ87MwBxtInHnbmAEMztgI4y8RjFfEAaGSmoYt4ABDrFo9Nge3MAQbi5AFwirnvicUDoIXJnjIVDwBiheJh7QFMY/oLWs94eFUQWMR8lztjKwBi4gFATDwADrbCBrdzPLwqCExvyv2ukwcAMfEAICYeAEfajN9nfSehXDysPQDq6x8PrwoCDMfYCuAw68xOxAPgLBNPVsQDgFiJeHhVEGAsTh4Ax1jqxlc8AE4x96Ok4gFArGg8rD2Asax21aoSD68KAjOZ/ppmbAVATDwAiIkHwKsWXNMWiodXBYE5rLDEdfIAICYeAMTEA+Almxn7Ii8elI6HtQdATbXi4VVBgCEYWwE8b9kBiXgAHGad8Yl4ABArFw+vCgLU5+QB8KQ1H9K9Eg8AYuIBQGyAeFh7AAUtfmmqGA+vCgLDWe3CZWwFQEw8AIiJB0DMLnaMePicgMoW3NQWjYedOUBlxlYAxMQDILPyv0rybph4WHsA1FE3HtYeAGUZWwEETEGuxAPgecvOSMQDgNhI8XBaBCiidDzszIFSPKT7ztgKgJh4ABAbLB7WHkAvrj8fVY+HtQdQ0+JXJ2MrAGLiAUBMPAAes/DYGC8ePkKgO+vYAeLhQwKoxtgKgJh4ADzgXyX5bMh4WHsA9DVGPHQeoJTLKNdlp409VBYO9/ni44f2k3gArob3WHh8STwAAuJx5WkrAGLDxEPtge5ciN4NM7b6aTO5+v2PP29/8Y///fc/t7+AE4jHO/EA3HbsJR7vBo7HT/oBnOdzU8Xj3UgLcx8b0JFL0EeetgIgJh4AxMQD4AseIrhv7Hj4dIE2LDw2BouHzw+gAmMrAGLiAbC1GYmbeXw2fDysPQDaGy8ebgEAujO2AviFecYe4gFwj2nHl8QDgNgM8XDGBGhsyHg4RQIn8ZDuTsZWAMTEA4CYeADcWKDuN2o8NoNIHzlwOAuPO5w8AIiJBwAx8QD4i+l3ZJ54+OCBA1l43DdwPHy0AL0YWwEQEw8A/ypJTDwAiI0dD68KAnTh5AGszn3nE8QD4BcWHnuIBwCx2eLh+AnQwPDxcMAEXuEh3ecYWwEQEw8AYuIBrMuW9GkzxMOrgsAhLDz2c/IAICYeAMTEA1iUEfcr5oyH7wSQsvCITBIPnzpAS8ZWAMTEA1iRf5XkReIBQGyeeHhVEKAZJw9gOW4uXycewOosPJ4gHgDEZo6HkynASaaKh7Mn8JCHdA9hbAVATDwAiIkHsBCr0KPMFg+vCgL7WXg8zckDgJh4ABATD2AV5tgHmj8evi7Alyw8XjFhPHwhAM5mbAUswRDiWOIBrMiI4kXiAUBsiXg4rgIca854OJACH7mDPJyxFbAc95evEw8AYqvEw6EV4EDTxsOxFLja3Du6OBzC2AqAmHgAEBMPYGb2nSdZKB6+Q4CFx1FmjodvCcBJjK0AiIkHMC3D6vOsFQ/fJFiZUfaBJo+H7wrAGYytgDmZNJxKPIAlmEMcSzwAiC0XDydZgNfNHw9nVViQ28SzGVsB83MTeTjxACC2YjycZwFetEQ8nFhhKZsbRFeAMxhbARATDwBi4gFMxVKzjUXj4esFi7DwOMkq8fAFAjiQsRUAMfEA5uEh3WbWjYe1B8DTFoqHexCAoxhbAZMwTmhJPIA5GTacSjwAiC0dD4dcgOesFQ/HWJiVe8HGjK2ACblTPJt4ABBbPR6OugBPWC4eDrMwn81doJ95A8ZWAMTEA4CYeABjs7nsQjx882AqFh5trBgP3y2AFzl5ABATD2BgHtLtRTwAiC0aj83tiZ05QMTJAxiV276OxAOYhIVHS+IBQEw8bpx/AfZbNx5OuDA0N3x9OXkAM3A72Jh4ABATDwBiS8fDq4IwqM2v1cyqPScPAGLiAUBMPIDBmDBXIB6/8KWE4Vh4dLF6PHztAJ7g5AFATDyAkXhItwjxACAmHl4VBIiJBzAM93Z1iAcwKguPjsQDgJh4fMHRGOA+8fiLwy/U566uFPEAhuSery/xACAmHgDExOPGq4JQ2eYnaWbVnXgAEBMPAGLiAVRnjFyQeHzL9xVqsvCoQDz+5RsJsJN4ABATD6A0D+nWJB4AxMTjF14VBNhDPIC63MCVJR7AMCw86hAPAGLi8YBTM8Bn4rHlXAxFuHWrTDyAMbixK0U8AIiJx9blcrn9BcA3xOMxg1dob/O7M7OqRjwAiInHlhscgIfEAyjHrLg+8Xjs9z/+vP0F9GAeUJB4fGHzTXUTBLAhHgDExAOoxUO6QxCPr5lcAdwhHgDExAMoxCl/FOLxLZMr6M7CoyzxACAmHgDExOMekytoyU9sIOIBFGXhUZl4ABATjwdMrgA+Ew+ghM2dmZlVceIBQOwi73tcLpfbX3/zX/igu+knqC5NxYnHLivEwzqHUlyaihOPXTbxAM7m0lScnccuvscAH4nHXvoBzfi51WdsFTC8ohQ/XjoSj8zc/fBlAHYSDwBidh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUDox4//A5g7GEmh/ByrAAAAAElFTkSuQmCC width = 420 height = 610>";
  if (vol_nivel == 2) ptr += "<img src=data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAhQAAAKOCAIAAABx5ReXAAAAAXNSR0IArs4c6QAAAARnQU1BAACxjwv8YQUAAAAJcEhZcwAAEnQAABJ0Ad5mH3gAAA7LSURBVHhe7d3RdePIEYbRoYNwChvaxjShTQqThKy1aFkDSSR+Euiu7r73xXr0OSTxoauA2cvLy8sPAEj86/q/ALCbeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiF1eXl6uf8KSLpfL9S+Y1+GX+lvx8KMCmMax/fh2bKUcAHzHzgOAmHgAzM/OAw7289fv618whb//+vf1r/85vByvgnj4jQHUt4nHGeV4FYytPtcMgDXdisdJvQJgdBbmAPNoM7N6JR4AxMQDgFgWDztzgLJaXqLvxMPOHGBQp17Aja0AiIkHALE4HtYeAAU1vjjfj4e1B8Bwzr50G1sBEBMPgOG1XyiIB8BsGqwbHomHnTnA4nbFw84cgI+MrQDG1mUaJB4AU2kzK3owHtYeACvbGw9rDwDeGVsBDGwzB2p2oy8eAMTEA4DY4/GwMwfoq+N1OIiHnTlAZS2v0sZWAMTEA4DYU/Gw9gDope8VOIuHtQdATY2vz8ZWAMTEA2A83bcG4gEwvPY7hWfjYWcOsKA4HnbmABhbAQymwshHPADG1mUgdEA8rD0AVvNIPKw9ABZnbAUwks2wp9fdvHgAEBMPAGLHxMPOHKCBOhfbB+NhZw7QXcdLsbEVADHxACAmHgBjKPKQ7pvH47H5/21nDrAOJw8AYuIBMIBq0x3xABhP9/cljoyHtQfAIp6Kh1cFAdZkbAVQXcG5jngADKbC1Ec8AIg9Gw+vCgIsyMkDoLTNTXmRJ5XEA4CYeAAQOz4e1h4ARyl7RT0gHl4VBGijzvXW2AqAmHgAEBMPgKJqPqT75ph4eFUQYClOHgDExAOgouIjHPEAGEC1lyLOioe1B8DEDouHVwUB1mFsBVBO/eGNeABUV3C0Ix4AxI6Mh1cFARbh5AFQy+bOu+bjSOIBQEw8AIidGw9rD4DIKJfNg+PhVUGAA5W9qBpbARATDwBi4gFQxRAP6b45Ph5eFQSYnpMHADHxAChhrDmNeABUVPzNhxbxsPYAmMwp8fCqIMDcjK0A+htuQiMeAOXUn9+IBwCxRvGwMweYyVnxsDMH2Glzez3E9dPYCoCYeAAQaxcPaw+Azwa9Np4YD2sPgNQoV05jKwBi4gFATDwAuhnxId03TeNhZw4wh3PjYWcOMCVjK4A+hh7GiAdACWONalrHw9oDYAKnx8PaA2A+xlYAHYw+hhEPgP6GG9KIBwCxDvGwMwcYXYt42JkDfLS5hx7xImlsBUBMPACI9YmHtQewrDkugI3iYe0B8KVBL4/GVgDExAOAmHgAtDPBQ7pvusXDzhxgXO3iYWcOMA1jK4BGZpq4iAdAH0PPY3rGw9oDYFBN42HtATAHYyuAFiabtYgHQAejT2LEA4BY53jYmQOMqHU87MyBBW1ulCe4EhpbARATDwBi/eNh7QHMbcqrXId4WHsAK5vjGmhsBUBMPACIiQfAieZ7SPdNiXjYmQOMpU887MwBhmZsBXCWiccq4gHQyExDF/EAINYtHpsC25kDDMTJA+AUc98TiwdAC5M9ZSoeAMQKxcPaA5jG9Be0nvHwqiCwiPkud8ZWAMTEA4CYeAAcbIUNbud4eFUQmN6U+10nDwBi4gFATDwAjrQZv8/6TkK5eFh7ANTXPx5eFQQYjrEVwGHWmZ2IB8BZJp6siAcAsRLx8KogwFicPACOsdSNr3gAnGLuR0nFA4BY0XhYewBjWe2qVSUeXhUEZjL9Nc3YCoCYeAAQEw+AZy24pi0UD68KAnNYYYnr5AFATDwAiIkHwFM2M/ZFXjwoHQ9rD4CaasXDq4IAQzC2AnjcsgMS8QA4zDrjE/EAIFYuHl4VBKjPyQPgQWs+pPtGPACIiQcAsQHiYe0BFLT4paliPLwqCAxntQuXsRUAMfEAICYeADG72DHi4XMCKltwU1s0HnbmAJUZWwEQEw+AzMr/Ksm7YeJh7QFQR914WHsAlGVsBRAwBXkjHgCPW3ZGIh4AxEaKh9MiQBGl42FnDpTiId13xlYAxMQDgNhg8bD2AHpx/fmoejysPYCaFr86GVsBEBMPAGLiAXCfhcfGePHwEQLdWccOEA8fEkA1xlYAxMQD4A7/KslnQ8bD2gOgrzHiofMApVxGuS5fLpfrX3zv56/f17+Ag3wedbidfSUegNuOWyw8viQeAAHxeONpKwBiw8RD7YHuXIjeDTO2erWZXJnSfuYhZjiVeLwTD8Btx17i8W7geLzSD+A8HtK9YaSFuY8N6Mgl6CNPWwEQEw8AYuIB8AUPEdw2djx8ukAbFh4bg8XD5wdQgbEVADHxANjajMTNPD4bPh7WHgDtjRcPtwAA3RlbAfzBPGMP8QC4xbTjS+IBQGyGeDhjAjQ2ZDycIoGTeEh3J2MrAGLiAUBMPACuLFD3GzUem0Gkjxw4nIXHDU4eAMTEA4CYeAD8w/Q7Mk88fPDAgSw8bhs4Hj5agF6MrQCIiQeAf5UkJh4AxMaOh1cFAbpw8gBW577zAeIB8AcLjz3EA4DYbPFw/ARoYPh4OGACz/CQ7mOMrQCIiQcAMfEA1mVL+rAZ4uFVQeAQFh77OXkAEBMPAGLiASzKiPsZc8bDdwJIWXhEJomHTx2gJWMrAGLiAazIv0ryJPEAIDZPPLwqCNCMkwewHDeXzxMPYHUWHg8QDwBiM8fDyRTgJFPFw9kTuMtDuocwtgIgJh4AxMQDWIhV6FFmi4dXBYH9LDwe5uQBQEw8AIiJB7AKc+wDzR8PXxfgSxYez5gwHr4QAGcztgKWYAhxLPEAVmRE8STxACC2RDwcVwGONWc8HEiBj9xBHs7YCliO+8vniQcAsVXi4dAKcKBp4+FYCrzZ3Du6OBzC2AqAmHgAEBMPYGb2nSdZKB6+Q4CFx1FmjodvCcBJjK0AiIkHMC3D6vOsFQ/fJFiZUfaBJo+H7wrAGYytgDmZNJxKPIAlmEMcSzwAiC0XDydZgOfNHw9nVViQ28SzGVsB83MTeTjxACC2YjycZwGetEQ8nFhhKZsbRFeAMxhbARATDwBi4gFMxVKzjUXj4esFi7DwOMkq8fAFAjiQsRUAMfEA5uEh3WbWjYe1B8DDFoqHexCAoxhbAZMwTmhJPIA5GTacSjwAiC0dD4dcgMesFQ/HWJiVe8HGjK2ACblTPJt4ABBbPR6OugAPWC4eDrMwn81doJ95A8ZWAMTEA4CYeABjs7nsQjx882AqFh5trBgP3y2AJzl5ABATD2BgHtLtRTwAiC0aj83tiZ05QMTJAxiV276OxAOYhIVHS+IBQEw8rpx/AfZbNx5OuDA0N3x9OXkAM3A72Jh4ABATDwBiS8fDq4IwqM2v1cyqPScPAGLiAUBMPIDBmDBXIB5/8KWE4Vh4dLF6PHztAB7g5AFATDyAkXhItwjxACAmHl4VBIiJBzAM93Z1iAcwKguPjsQDgJh4fMHRGOA28fiHwy/U566uFPEAhuSery/xACAmHgDExOPKq4JQ2eYnaWbVnXgAEBMPAGLiAVRnjFyQeHzL9xVqsvCoQDz+zzcSYCfxACAmHkBpHtKtSTwAiInHH7wqCLCHeAB1uYErSzyAYVh41CEeAMTE4w6nZoDPxGPLuRiKcOtWmXgAY3BjV4p4ABATj63L5XL9C4BviMd9Bq/Q3uZ3Z2ZVjXgAEBOPLTc4AHeJB1COWXF94nHfz1+/r38BPZgHFCQeX9h8U90EAWyIBwAx8QBq8ZDuEMTjayZXADeIBwAx8QAKccofhXh8y+QKurPwKEs8AIiJBwAx8bjF5Apa8hMbiHgARVl4VCYeAMTE4w6TK4DPxAMoYXNnZmZVnHgAELvI+x6Xy+X613/5L3zQ3fQTVJem4sRjlxXiYZ1DKS5NxYnHLpt4AGdzaSrOzmMX32OAj8RjL/2AZvzc6jO2ChheUYofLx2JR2bufvgyADuJBwAxOw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACAmHgDExAOAmHgAEBMPAGLiAUBMPACIiQcAMfEAICYeAMTEA4CYeAAQEw8AYuIBQEw8AIiJBwAx8QAgJh4AxMQDgJh4ABATDwBi4gFATDwAiIkHADHxACD048d/ABy8WlIYoK9eAAAAAElFTkSuQmCC width = 420 height = 610>";
 // ptr += "<img src="+filename+">"
  ptr += "</body>\n";
  ptr += "</html>\n";
  return ptr;
}
